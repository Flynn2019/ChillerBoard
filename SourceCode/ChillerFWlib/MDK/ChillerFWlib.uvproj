# Keil uVision project ChillerFWlib.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ChillerFWlib (library)
  AfterMake: E:\ChillerMonitor\ChillerFWlib\MDK\copylib.bat
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\USER\inc;..\USER\STM32FW;..\USER\STM32FW\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group lib
    ../USER/src/: Delay_Timer.c J12864.c STM32Flash.c Timer.c
