# Keil uVision project Chiller_Monitor.uvproj, settings and files
target Chiller_Monitor (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Chiller_Monitor +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\USER\inc;..\USER\inc\inc;..\USER\inc\STM32FW;..\USER\inc\STM32FW\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ../USER/src/: key.c Display.c IO_Process.c Tempra_AD.c flash.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group MDK
    ./APP/: main.c
  group Lib
    ../USER/: STM32F103FWlib.lib ChillerFWlib.lib
